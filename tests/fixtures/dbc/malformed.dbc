VERSION "1.0"

NS_ :

BS_:

BU_: Node

BO_ not_a_frame_id BrokenFrame: 8 Node
 SG_ SignalOne : 0|8@1+ (1,0) [0|255] "" Node
