VERSION "1.0"

NS_ :

BS_:

BU_: BodyController

BO_ 1792 DoorFrame: 8 BodyController
 SG_ DoorState : 0|8@1+ (1,0) [0|3] "état" BodyController

CM_ BO_ 1792 "Türstatus — température naïve — 车门状态";
